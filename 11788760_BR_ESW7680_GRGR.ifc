Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-02-07T14:39:42
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Feb 07 14:39:42 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\835b0d04-1484-4f43-8f82-05342338e728\098fd995-b50f-45f3-a174-419dc172c50a\ifc * Database version: 5507 * Database creation date: Mon Feb 07 14:39:42 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Feb 07 14:39:42 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Feb 07 14:39:42 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11788760_BR_ESW7680_GRGR:30768030_BR_11788760_ESW7680_GRGR, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 30768030_BR_11788760_ESW7680_GRGR
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 30768030_BR_11788760_ESW7680_GRGR
Type - Pset_ProvisionForVoid - Width: 757 mm; Height: 275 mm; Depth: 608 mm
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_GRGR, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcDistributionPort, Port_351887
Description: Flow; FlowDirection: SOURCEANDSINK
